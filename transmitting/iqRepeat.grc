options:
  parameters:
    comment: |-
      Replay one prepared RFUAV clip through a USRP B210.

      The file must come from prepare_clip.py. A file source does not know the
      rate of its file, thus a source at 100 Msps that goes out at 10 Msps is 10
      times too slow and 10 times too narrow, and the replay is not the drone.

      Keep center_freq the same for every class. prepare_clip.py --offset-hz
      chooses which part of the source band arrives here.
    generate_options: qt_gui
    id: iqRepeat
    output_language: python
    title: IQ repeat
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: |-
      One value for the whole campaign, every class included. A centre
      frequency that follows the class is a perfect cue for the classifier.
    value: '2440000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      The rate of the prepared file. Read it from the .json that
      prepare_clip.py wrote beside the .iq. It is not the rate of the source.
    value: '10000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: |-
      A fixed value, not a slider. The gain gives the signal-to-noise
      ratio of the whole session and nothing in the capture records it. A slider
      that somebody moved in the middle of a session spoils that session in
      silence. Write this number in the session notes.
    value: '70'
  states: {}
- name: tx_on
  id: variable
  parameters:
    comment: |-
      Set 0 to record the noise class. The USRP stays on, at the same
      frequency and the same gain, and it sends zeros. A noise class that is
      taken with the USRP off teaches the model to answer the question "is the
      USRP on".
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      The output of prepare_clip.py, never the RFUAV source.

      repeat joins the end of the file to its start. The phase makes a step
      there, and the step is a wide transient once for each loop. Give every
      class clips of the same length, or the period of that transient becomes a
      class cue.
    file: C:\Users\Nojus\PycharmProjects\RF-Scan\transmitting\clips\at9s_pack1_7-8s.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      The switch of the noise class.

      No throttle block is here, and that is deliberate. The USRP sink gives the
      rate of the flow graph. A throttle keeps its own time against the clock of
      the computer, thus the two move apart and the transmitter has an underrun.
      Use a throttle only when no hardware block is in the flow graph.
    const: tx_on
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
